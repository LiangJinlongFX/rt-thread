# Keil uVision project project.uvprojx, settings and files
target rtthread-lpc5411x (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC54114J256BD64:cm4 NXP
  pack: NXP.LPC54114_DFP.13.0.0
  cpu: IRAM(0x20000000,0x010000) IRAM2(0x20010000,0x010000) IROM(0x00000000,0x040000) XRAM(0x20020000,0x8000) XRAM2(0x04000000,0x8000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread-lpc5411x
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: __RTTHREAD__, CORE_M4, CHIP_LPC5411X
  c misc: --library_interface=armcc --library_type=standardlib --diag_suppress=66,1296,186
  c include: applications;.;bsp;.;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m4;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\finsh;.;..\..\include;LPCXpresso_SDK\chip_5411x\inc;..\..\examples\utest\testcases\kernel
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT6: RAM 0x20020000 size 0x8000
  memory RVCT7: RAM 0x4000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20010000 size 0x10000
  scatter file: .\lpc5411x_flash.scf
  link misc: --list_mapping_symbols --load_addr_map_info
  group Applications
    applications/: main.c
  group BSP
    bsp/: board.c drv_uart.c
    ./LPCXpresso_SDK/chip_5411x/libs/: keil_lib_power.lib
  group CPU
    ../../libcpu/arm/common/: showmem.c div0.c backtrace.c
    ../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: ringblk_buf.c waitqueue.c completion.c workqueue.c ringbuffer.c dataqueue.c pipe.c
  group finsh
    ../../components/finsh/: finsh_node.c finsh_init.c finsh_token.c msh.c finsh_compiler.c finsh_heap.c shell.c cmd.c finsh_var.c finsh_ops.c finsh_vm.c finsh_error.c finsh_parser.c
  group Kernel
    ../../src/: device.c thread.c irq.c scheduler.c ipc.c kservice.c idle.c mem.c mempool.c components.c memheap.c object.c clock.c timer.c
  group LPCXpresso
    LPCXpresso_SDK/chip_5411x/src/: sysinit_5411x.c timer_5411x.c adc_5411x.c rtc_ut.c sct_pwm_5411x.c uart_5411x.c ring_buffer.c stopwatch_5411x.c dma_service_5411x.c flexcomm_5411x.c i2cs_5411x.c syscon_5411x.c spis_5411x.c iap.c spi_common_5411x.c chip_5411x.c pll_5411x.c dmic_5411x.c fpu_init.c i2s_5411x.c clock_5411x.c spim_5411x.c sct_5411x.c i2cm_5411x.c dma_5411x.c
    LPCXpresso_SDK/chip_5411x/startup/: keil_startup_LPC5411x.s
