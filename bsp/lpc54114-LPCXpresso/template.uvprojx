# Keil uVision project template.uvprojx, settings and files
target rtthread-lpc5411x (ARM-ADS)
  device: LPC54114J256BD64:cm4 NXP
  pack: NXP.LPC54114_DFP.13.0.0
  cpu: IRAM(0x20000000,0x010000) IRAM2(0x20010000,0x010000) IROM(0x00000000,0x040000) XRAM(0x20020000,0x8000) XRAM2(0x04000000,0x8000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread-lpc5411x
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: CORE_M4,CHIP_LPC5411X
  c misc: --library_interface=armcc --library_type=standardlib --diag_suppress=66,1296,186
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT6: RAM 0x20020000 size 0x8000
  memory RVCT7: RAM 0x4000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20010000 size 0x10000
